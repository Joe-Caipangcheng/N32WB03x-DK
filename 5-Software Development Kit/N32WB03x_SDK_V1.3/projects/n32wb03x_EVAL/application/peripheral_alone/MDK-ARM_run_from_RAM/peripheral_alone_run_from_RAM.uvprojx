# Keil uVision project peripheral_alone_run_from_RAM.uvprojx, settings and files
target N32WB03x (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32WB031 Nationstech
  pack: Nationstech.N32WB03X_DFP.1.0.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x1000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(64000000) ELITTLE
  output: Demo
  AfterMake: fromelf --bin --output=.\bin\Demo.bin .\Objects\Demo.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32WB03X, USE_STDPERIPH_DRIVER, USE_HSI_64Mx, TEST_200MS_WAKEUPx,RUN_FROM_RAM
  c include: ..\inc;..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\firmware\n32wb03x_std_periph_driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x2000000 size 0x8000
  memory RVCT9: RAM 0x20008000 size 0x4000
  scatter file: .\run_from_RAM.sct
  group STARTUP
    ../../../../../firmware/CMSIS/device/startup/: startup_n32wb03x.s
  group CMSIS
    ../../../../../firmware/CMSIS/device/: system_n32wb03x.c
  group FWLB
    ../../../../../firmware/n32wb03x_std_periph_driver/src/: misc.c n32wb03x_adc.c n32wb03x_crc.c n32wb03x_dma.c n32wb03x_exti.c n32wb03x_gpio.c n32wb03x_rcc.c n32wb03x_tim.c n32wb03x_usart.c n32wb03x_pwr.c n32wb03x_rtc.c
  group USER
    ../src/: main.c n32wb03x_it.c app_rtc.c app_tim.c app_adc.c app_usart.c app_gpio.c
  group DOC
    ../: readme.txt
