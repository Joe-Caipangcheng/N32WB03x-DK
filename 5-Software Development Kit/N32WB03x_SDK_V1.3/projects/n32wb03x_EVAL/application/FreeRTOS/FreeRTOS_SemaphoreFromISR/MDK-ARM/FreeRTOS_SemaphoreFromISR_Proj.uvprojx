# Keil uVision project FreeRTOS_SemaphoreFromISR_Proj.uvprojx, settings and files
target N32WB03X (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32WB031 Nationstech
  pack: Nationstech.N32WB03X_DFP.1.0.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x1000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(64000000) ELITTLE
  output: FreeRTOS_SemaphoreFromISR_Proj +hex
  AfterMake: fromelf --bin --output=.\bin\FreeRTOS_SemaphoreFromISR_Proj.bin .\Objects\FreeRTOS_SemaphoreFromISR_Proj.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 wLevel=2
  c define: N32WB03X, USE_STDPERIPH_DRIVER
  c include: ..\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32wb03x_std_periph_driver\inc;..\..\..\..\..\..\middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM0;..\..\..\..\..\..\middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS;..\..\..\..\..\..\middlewares\Third_Party\FreeRTOS\Source\include
  library: MicroLIB
  memory RVCT4: ROM 0x1000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32wb03x.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32wb03x.c
  group FWLB
    ../../../../../../firmware/n32wb03x_std_periph_driver/src/: misc.c n32wb03x_gpio.c n32wb03x_rcc.c n32wb03x_usart.c n32wb03x_exti.c
  group middlewares\Third_Party\FreeRTOS\Source
    ../../../../../../middlewares/Third_Party/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
  group middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS
    ../../../../../../middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM0
    ../../../../../../middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM0/: port.c
  group middlewares\Third_Party\FreeRTOS\Source\portable\MemMang
    ../../../../../../middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group USER
    ../src/: main.c n32wb03x_it.c
  group DOC
    ../: readme.txt
