# Keil uVision project app_usart.uvprojx, settings and files
target N32WB03x (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32WB031 Nationstech
  pack: Nationstech.N32WB03X_DFP.1.0.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x1000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(64000000) ELITTLE
  output: app_usart +hex
  AfterMake: fromelf --bin --output=.\bin\app_usart.bin .\Objects\app_usart.axf
  AfterMake: cmd.exe /C copy .\bin\app_usart.bin ..\..\..\..\..\utilities\dfu\Image\APP2.bin
  c flags: oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32WB03x, USE_STDPERIPH_DRIVER
  c include: ..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\firmware\n32wb03x_std_periph_driver\inc;..\inc;..\..\..\..\..\middlewares\Nationstech\ble_library\ns_library\error;..\..\..\..\..\middlewares\Nationstech\ble_library\ns_library\dfu;..\..\..\..\..\middlewares\Nationstech\ble_library\ns_library\scheduler;..\..\common
  library: MicroLIB
  memory RVCT4: ROM 0x1020000 size 0x1c000
  memory RVCT9: RAM 0x20004000 size 0x8000
  group STARTUP
    ../../../../../firmware/CMSIS/device/startup/: startup_n32wb03x.s
  group CMSIS
    ../../../../../firmware/CMSIS/device/: system_n32wb03x.c
  group FWLB
    ../../../../../firmware/n32wb03x_std_periph_driver/src/: misc.c n32wb03x_crc.c n32wb03x_gpio.c n32wb03x_pwr.c n32wb03x_rcc.c n32wb03x_usart.c n32wb03x_qflash.c
  group USER
    ../src/: main.c
  group NS_LIB
    ../../../../../middlewares/Nationstech/ble_library/ns_library/error/: ns_error.c
    ../../../../../middlewares/Nationstech/ble_library/ns_library/scheduler/: ns_scheduler.c
  group DOC
    ../: readme.txt
  group NS_DFU
    ../../common/: dfu_usart.c dfu_led.c dfu_crc.c dfu_delay.c
    ../../../../../middlewares/Nationstech/ble_library/ns_library/dfu/: ns_dfu_boot.c
