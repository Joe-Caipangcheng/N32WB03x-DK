# Keil uVision project Transmit_CTS.uvprojx, settings and files
target N32WB03X (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32WB031 Nationstech
  pack: Nationstech.N32WB03X_DFP.1.0.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x1000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(64000000) ELITTLE
  output: Transmit_CTS +hex
  AfterMake: fromelf --bin --output=.\bin\Transmit_CTS.bin .\Objects\Transmit_CTS.axf
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32WB03X, USE_STDPERIPH_DRIVER, USE_FULL_ASSERT
  c include: ..\..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\..\firmware\n32wb03x_std_periph_driver\inc;..\inc;..\..\..\..\..\bsp\inc
  library: MicroLIB
  memory RVCT4: ROM 0x1000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTUP
    ../../../../../../../firmware/CMSIS/device/startup/: startup_n32wb03x.s
  group CMSIS
    ../../../../../../../firmware/CMSIS/device/: system_n32wb03x.c
  group FWLB
    ../../../../../../../firmware/n32wb03x_std_periph_driver/src/: misc.c n32wb03x_gpio.c n32wb03x_lpuart.c n32wb03x_rcc.c n32wb03x_usart.c
  group USER
    ../src/: main.c n32wb03x_it.c
  group BSP
    ../../../../../bsp/src/: log.c
  group DOC
    ../: readme.txt
