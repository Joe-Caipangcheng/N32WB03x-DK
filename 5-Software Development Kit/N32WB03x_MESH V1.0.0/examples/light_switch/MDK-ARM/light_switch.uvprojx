# Keil uVision project light_switch.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32WB031 Nationstech
  pack: Nationstech.N32WB03X_DFP.1.1.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x1000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: light_switch +hex
  AfterMake: fromelf --bin --output=.\light_switch.bin .\Objects\light_switch.axf
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32WB03X, USE_STDPERIPH_DRIVER, MCU_LSC_SEL_LSI
  c include: ..\..\..\firmware\CMSIS\core;..\..\..\firmware\CMSIS\device;..\..\..\firmware\n32wb03x_std_periph_driver\inc;..\..\..\middlewares\Nationstech\ble_library\ns_ble_profile\dis\diss\api;..\..\..\middlewares\Nationstech\ble_library\ns_ble_profile\bas\bass\api;..\..\..\middlewares\Nationstech\ble_library\ns_ble_profile\hogp;..\..\..\middlewares\Nationstech\ble_library\ns_ble_profile\hogp\hogpd\api;..\..\..\middlewares\Nationstech\ble_library\ns_ble_profile\hogp\hogpd\src;..\..\..\middlewares\Nationstech\ble_library\ns_ble_profile\custom;..\..\..\middlewares\Nationstech\ble_library\ns_ble_profile\custom\custs\api;..\..\..\middlewares\Nationstech\ble_library\ns_ble_profile\hrp;..\..\..\middlewares\Nationstech\ble_library\ns_ble_profile\hrp\hrps\api;..\..\..\middlewares\Nationstech\ble_library\ns_ble_profile\hrp\hrps\src;..\..\..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ahi\api;..\..\..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\hl\api;..\..\..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\hl\inc;..\..\..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\hl\src\gap;..\..\..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\hl\src\gatt;..\..\..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\hl\src\l2c;..\..\..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\ll\api;..\..\..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\ll\src;..\..\..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\ll\src\llc;..\..\..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\ll\src\lld;..\..\..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\ll\src\llm;..\..\..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\em\api;..\..\..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\hci\api;..\..\..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\sch\api;..\..\..\middlewares\Nationstech\ble_library\ns_ble_stack\modules\aes\api;..\..\..\middlewares\Nationstech\ble_library\ns_ble_stack\modules\common\api;..\..\..\middlewares\Nationstech\ble_library\ns_ble_stack\modules\dbg\api;..\..\..\middlewares\Nationstech\ble_library\ns_ble_stack\modules\ecc_p256\api;..\..\..\middlewares\Nationstech\ble_library\ns_ble_stack\modules\h4tl\api;..\..\..\middlewares\Nationstech\ble_library\ns_ble_stack\modules\ke\api;..\..\..\middlewares\Nationstech\ble_library\ns_ble_stack\modules\rwip\api;..\..\..\middlewares\Nationstech\ble_library\ns_ble_stack\rfinit\api;..\..\..\middlewares\Nationstech\ble_library\ns_ble_stack\arch;..\..\..\middlewares\Nationstech\ble_library\ns_ble_stack\modules\common\api;..\..\..\middlewares\Nationstech\ble_library\ns_ble_stack\modules\common\src;..\..\..\middlewares\Nationstech\ble_library\ns_ble_stack\stack_common;..\inc\rw;..\inc\app_profile;..\..\..\middlewares\Nationstech\ble_library\ns_ble_stack\arch;..\..\..\middlewares\Nationstech\ble_library\ns_library\sleep;..\..\..\bsp;..\inc;..\..\..\middlewares\Nationstech\ble_library\ns_library\delay;..\..\..\mesh\task;..\..\..\common\api;..\..\..\common\inc;..\..\..\encryption;..\..\..\encryption\micro-ecc;..\..\..\mesh\access\api;..\..\..\mesh\access\include;..\..\..\mesh\bearer\api;..\..\..\mesh\bearer\include;..\..\..\mesh\config\api;..\..\..\mesh\config\include;..\..\..\mesh\core\api;..\..\..\mesh\core\include;..\..\..\mesh\encryption\api;..\..\..\mesh\encryption\include;..\..\..\mesh\file_system\api;..\..\..\mesh\file_system\include;..\..\..\mesh\gatt\api;..\..\..\mesh\gatt\include;..\..\..\mesh\packet\api;..\..\..\mesh\packet\include;..\..\..\mesh\prov\api;..\..\..\mesh\prov\include;..\..\..\mesh\stack\api;..\..\..\models\foundation\config\include;..\..\..\models\model_spec\common\include;..\..\..\models\model_spec\generic_onoff\include;..\..\..\mesh\task;..\..\..\encryption\aes;..\..\..\rtt_log;..\..\..\mesh\schedule\inc;..\..\..\mesh\schedule\api;..\..\..\mesh\stack
  memory RVCT4: ROM 0x1000000 size 0x3b000
  memory RVCT9: RAM 0x20004000 size 0x8000
  scatter file: .\light_switch.sct
  link misc: ..\..\..\middlewares\Nationstech\ble_library\ns_ble_stack\symdef\symbol_g15_mesh.obj
  group fwlib
    ../../../firmware/CMSIS/device/startup/: startup_n32wb03x.s
    ../../../firmware/CMSIS/device/: system_n32wb03x.c
    ../../../firmware/n32wb03x_std_periph_driver/src/: misc.c n32wb03x_exti.c n32wb03x_gpio.c n32wb03x_iwdg.c n32wb03x_lpuart.c n32wb03x_pwr.c n32wb03x_qflash.c n32wb03x_rcc.c n32wb03x_usart.c n32wb03x_tim.c
  group src
    ../src/: main.c
    ../../../mesh/stack/src/: app_onoff.c
  group ble_stack
    ../../../middlewares/Nationstech/ble_library/ns_ble_stack/host_lib/: n32wb03x_host_lib.lib
    ../../../middlewares/Nationstech/ble_library/common_file/: rwip_fifo_isr.c
    ../../../middlewares/Nationstech/ble_library/ns_ble_profile/: prf.c prf_utils.c
    ../../../middlewares/Nationstech/ble_library/ns_ble_stack/stack_common/: rwip.c rwip_driver.c
    ../src/: app_task.c app.c
  group mesh_task
    ../../../mesh/stack/: lib_mesh_stack.lib
    ../../../mesh/task/: mesh_app_task.c mesh_app.c
  group bsp
    ../../../bsp/: bsp_led.c bsp_lpuart.c bsp_button.c bsp_wdt.c
    ../../../middlewares/Nationstech/ble_library/ns_library/sleep/: ns_sleep.c
  group Generic OnOff Model
    ../../../models/model_spec/common/src/: model_common.c
    ../../../models/model_spec/generic_onoff/src/: generic_onoff_client.c generic_onoff_server.c
